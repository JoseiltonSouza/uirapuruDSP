options:
  parameters:
    author: LUCIANO BAROSI
    copyright: MIT
    generate_options: no_gui
    id: UIRAPURU_flow_NOGUI
    output_language: python
    run_options: run
    title: Spectrometer
  states: {}

blocks:
- name: Alt
  id: variable
  parameters:
    value: '84'
  states: {}
- name: Az
  id: variable
  parameters:
    value: '0'
  states: {}
- name: USRP
  id: variable
  parameters:
    value: '"addr=192.168.10.2"'
  states: {}
- name: csv
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: custom_window
  id: variable
  parameters:
    value: sinc*np.hamming(4*vec_length)
  states: {}
- name: file_size_MB
  id: variable
  parameters:
    value: np.round(vec_length * n_samples * 4 / 1024 / 1024,2)
  states: {}
- name: fit
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 1100e6
  states: {}
- name: gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: heigth
  id: variable
  parameters:
    value: '-35.9081'
  states: {}
- name: instr
  id: variable
  parameters:
    value: '"cadeia_01"'
  states: {}
- name: lat
  id: variable
  parameters:
    value: '-7.2117'
  states: {}
- name: lon
  id: variable
  parameters:
    value: '-35.9081'
  states: {}
- name: mode
  id: variable
  parameters:
    value: '"59"'
  states: {}
- name: n_integration
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: n_samples
  id: variable
  parameters:
    value: '11000'
  states: {}
- name: name
  id: variable
  parameters:
    value: '"BINGO"'
  states: {}
- name: prefix
  id: variable
  parameters:
    value: '"../data/raw/GNURADIO/UIRAPURU_" + instr'
  states: {}
- name: rtl_string
  id: variable
  parameters:
    value: '"rtl=0"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 25e6
  states: {}
- name: sinc
  id: variable
  parameters:
    value: np.sinc(sinc_sample_locations/np.pi)
  states: {}
- name: sinc_sample_locations
  id: variable
  parameters:
    value: np.arange(-np.pi*4/2.0, np.pi*4/2.0, np.pi/vec_length)
  states: {}
- name: teles
  id: variable
  parameters:
    value: '"UIRAPURU"'
  states: {}
- name: time_to_save_min
  id: variable
  parameters:
    value: np.round((vec_length * n_integration * n_samples / samp_rate)/60, 1)
  states: {}
- name: timezone
  id: variable
  parameters:
    value: '"America/Recife"'
  states: {}
- name: vec_length
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: vec_length
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: 2*vec_length
    type: complex
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: 3*vec_length
    type: complex
  states: {}
- name: blocks_integrate_xx_0_0_0
  id: blocks_integrate_xx
  parameters:
    decim: n_integration
    type: float
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[-vec_length:]
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[2*vec_length:3*vec_length]
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[1*vec_length:2*vec_length]
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[0:vec_length]
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/vec_length
    type: float
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/n_integration
    type: float
    vlen: vec_length
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: vec_length
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vec_length
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(vec_length)
  states: {}
- name: fits_sink_fits_sink_0
  id: fits_sink_fits_sink
  parameters:
    Alt: Alt
    Az: Az
    fit: fit
    freq: freq
    heigth: heigth
    instr: instr
    lat: lat
    lon: lon
    mode: mode
    n_samples: n_samples
    prefix: prefix
    samp_rate: samp_rate
    teles: teles
    tz: America/Recife
    vec_length: vec_length
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    vlen: vec_length
    x_start: freq - samp_rate/2
    x_step: samp_rate/vec_length
    ymin: '0'
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: freq
    dev_addr: USRP
    gain0: gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    stream_args: peak=0.003906
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_add_xx_0, '0', fft_vxx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_correctiq_0, '0', blocks_delay_0, '0']
- [blocks_correctiq_0, '0', blocks_delay_0_0, '0']
- [blocks_correctiq_0, '0', blocks_delay_0_0_0, '0']
- [blocks_correctiq_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_delay_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_delay_0_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [blocks_delay_0_0_0, '0', blocks_stream_to_vector_0_0_0_0, '0']
- [blocks_integrate_xx_0_0_0, '0', blocks_multiply_const_xx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_0_0_0_0, '0', blocks_add_xx_0, '3']
- [blocks_multiply_const_xx_0, '0', blocks_integrate_xx_0_0_0, '0']
- [blocks_multiply_const_xx_0_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', fits_sink_fits_sink_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_stream_to_vector_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_0, '0', blocks_correctiq_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
